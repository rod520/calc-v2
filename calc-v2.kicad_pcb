File: calc-v2.kicad_pcb (KiCad board)
At the start: 2 copper layers, 32 parts, among them U1 W25Q128JVS, U2 NCP1117-3.3_SOT223, U3 BQ24074RGT, U4 TPS61165DBV, U5 RP2350B, U6 APS6404L-3SQRx-ZR

Commit message: more changes
Parts:
- added SW1: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 20.3)
- added SW10: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 88.2)
- added SW11: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 20.3)
- added SW12: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 27.8)
- added SW13: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 35.4)
- added SW14: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 42.9)
- added SW15: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 50.5)
- added SW16: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 58.0)
- added SW17: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 65.6)
- added SW18: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 73.1)
- added SW19: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 80.7)
- added SW2: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 27.8)
- added SW20: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (37.3, 88.2)
- added SW21: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 20.3)
- added SW22: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 27.8)
- added SW23: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 35.4)
- added SW24: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 42.9)
- added SW25: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 50.5)
- added SW26: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 58.0)
- added SW27: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 65.6)
- added SW28: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 73.1)
- added SW29: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 80.7)
- added SW3: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 35.4)
- added SW30: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (50.6, 88.2)
- added SW31: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 20.3)
- added SW32: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 27.8)
- added SW33: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 35.4)
- added SW34: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 42.9)
- added SW35: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 50.5)
- added SW36: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 58.0)
- added SW37: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 65.6)
- added SW38: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 73.1)
- added SW39: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 80.7)
- added SW4: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 42.9)
- added SW40: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (63.9, 88.2)
- added SW41: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 20.3)
- added SW42: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 27.8)
- added SW43: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 35.4)
- added SW44: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 42.9)
- added SW45: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 50.5)
- added SW46: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 58.0)
- added SW47: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 65.6)
- added SW48: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 73.1)
- added SW49: SW_Push_45deg, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (77.2, 80.7)
- added SW5: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 50.5)
- added SW6: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 58.0)
- added SW7: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 65.6)
- added SW8: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 73.1)
- added SW9: TS04-66-43-BK-100-SMT, AAAAA:SW_TS04-66-43-BK-100-SMT, F.Cu at (23.9, 80.7)
- moved U5 166.6 mm to (185.1, 22.6)
- moved C10 71.8 mm to (87.9, 29.7)
- moved C11 71.8 mm to (87.9, 31.7)
- moved C12 71.8 mm to (87.9, 33.7)
- moved C13 71.8 mm to (87.9, 35.6)
- moved C14 71.8 mm to (87.9, 37.6)
- moved C15 71.8 mm to (87.9, 39.6)
- moved C16 71.8 mm to (90.8, 29.7)
- moved C2 71.8 mm to (85.1, 29.7)
- moved C24 71.8 mm to (90.8, 31.7)
- moved C25 71.8 mm to (90.8, 33.7)
- moved C26 71.8 mm to (90.8, 35.6)
- moved C27 71.8 mm to (90.8, 37.6)
- moved C28 71.8 mm to (90.8, 39.6)
- moved C29 71.8 mm to (93.7, 29.7)
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
Commit message: components
Parts:
- added C34: 1u, Capacitor_SMD:C_0402_1005Metric, F.Cu at (202.6, 60.5)
- SW1, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW2, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW3, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW4, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW5, SW6, SW7, SW8, SW9: value TS04-66-43-BK-100-SMT -> SW_Push_45deg
- moved SW43 233.3 mm to (310.4, 30.0)
- moved SW44 219.5 mm to (296.4, 30.0)
- moved SW45 206.0 mm to (282.3, 30.0)
- moved SW46 193.0 mm to (268.2, 30.0)
- moved SW47 180.4 mm to (254.1, 30.0)
- moved SW48 168.4 mm to (240.0, 30.0)
- moved SW36 125.1 mm to (181.4, 101.0)
- moved SW16 125.1 mm to (154.8, 101.0)
- moved SW26 125.1 mm to (168.1, 101.0)
- moved SW1 125.1 mm to (141.4, 63.3)
- moved SW10 125.1 mm to (141.4, 131.2)
- moved SW2 125.1 mm to (141.4, 70.8)
- moved SW3 125.1 mm to (141.4, 78.4)
- moved SW31 125.1 mm to (181.4, 63.3)
- moved SW32 125.1 mm to (181.4, 70.8)
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Connections:
- SW1 pad 2: Net-(SW1-Pad2) -> SW_R1
- SW10 pad 1: Net-(SW10-Pad1) -> SW_C4
- SW10 pad 2: Net-(SW10-Pad2) -> SW_R2
- SW11 pad 1: Net-(SW11-Pad1) -> SW_C5
- SW11 pad 2: Net-(SW11-Pad2) -> SW_R2
- SW12 pad 2: unconnected-(SW12-Pad2) -> SW_R2
- SW13 pad 1: Net-(SW13-Pad1) -> SW_C1
- SW13 pad 2: Net-(SW13-Pad2) -> SW_R3
- SW14 pad 1: Net-(SW14-Pad1) -> SW_C2
- SW14 pad 2: Net-(SW14-Pad2) -> SW_R3
- SW15 pad 1: Net-(SW15-Pad1) -> SW_C3
- SW15 pad 2: Net-(SW15-Pad2) -> SW_R3
- SW16 pad 1: Net-(SW10-Pad3) -> SW_C4
- SW16 pad 2: Net-(SW16-Pad2) -> SW_R3
- SW17 pad 1: Net-(SW11-Pad3) -> SW_C5
- SW17 pad 2: Net-(SW17-Pad2) -> SW_R3
- SW18 pad 1: Net-(SW12-Pad3) -> Net-(SW12-Pad1)
- SW18 pad 2: unconnected-(SW18-Pad2) -> SW_R3
- SW19 pad 1: Net-(SW13-Pad3) -> SW_C1
- SW19 pad 2: Net-(SW19-Pad2) -> SW_R4
- SW2 pad 2: Net-(SW2-Pad2) -> SW_R1
- SW20 pad 1: Net-(SW14-Pad3) -> SW_C2
- SW20 pad 2: Net-(SW20-Pad2) -> SW_R4
- SW21 pad 1: Net-(SW15-Pad3) -> SW_C3
- SW21 pad 2: Net-(SW21-Pad2) -> SW_R4
- SW22 pad 1: Net-(SW16-Pad3) -> SW_C4
- SW22 pad 2: Net-(SW22-Pad2) -> SW_R4
- SW23 pad 1: Net-(SW17-Pad3) -> SW_C5
- SW23 pad 2: Net-(SW23-Pad2) -> SW_R4
- SW24 pad 1: Net-(SW18-Pad3) -> Net-(SW12-Pad1)
- SW24 pad 2: unconnected-(SW24-Pad2) -> SW_R4
- SW25 pad 1: Net-(SW19-Pad3) -> SW_C1
- SW25 pad 2: Net-(SW25-Pad2) -> SW_R5
- SW26 pad 1: Net-(SW20-Pad3) -> SW_C2
- SW26 pad 2: Net-(SW26-Pad2) -> SW_R5
- SW27 pad 1: Net-(SW21-Pad3) -> SW_C3
- SW27 pad 2: Net-(SW27-Pad2) -> SW_R5
- SW28 pad 1: Net-(SW22-Pad3) -> SW_C4
- SW28 pad 2: Net-(SW28-Pad2) -> SW_R5
- SW29 pad 1: Net-(SW23-Pad3) -> SW_C5
- SW29 pad 2: Net-(SW29-Pad2) -> SW_R5
- SW3 pad 2: Net-(SW3-Pad2) -> SW_R1
- SW30 pad 1: Net-(SW24-Pad3) -> Net-(SW12-Pad1)
- SW30 pad 2: unconnected-(SW30-Pad2) -> SW_R5
- SW31 pad 1: Net-(SW25-Pad3) -> SW_C1
- SW31 pad 2: Net-(SW31-Pad2) -> SW_R6
- SW32 pad 1: Net-(SW26-Pad3) -> SW_C2
- SW32 pad 2: Net-(SW32-Pad2) -> SW_R6
- SW33 pad 1: Net-(SW27-Pad3) -> SW_C3
- SW33 pad 2: Net-(SW33-Pad2) -> SW_R6
- SW34 pad 1: Net-(SW28-Pad3) -> SW_C4
- SW34 pad 2: Net-(SW34-Pad2) -> SW_R6
- SW35 pad 1: Net-(SW29-Pad3) -> SW_C5
- SW35 pad 2: Net-(SW35-Pad2) -> SW_R6
- SW36 pad 1: Net-(SW30-Pad3) -> Net-(SW12-Pad1)
- SW36 pad 2: unconnected-(SW36-Pad2) -> SW_R6
- SW37 pad 1: Net-(SW31-Pad3) -> SW_C1
- SW37 pad 2: Net-(SW37-Pad2) -> SW_R7
- SW38 pad 1: Net-(SW32-Pad3) -> SW_C2
- SW38 pad 2: Net-(SW38-Pad2) -> SW_R7
- SW39 pad 1: Net-(SW33-Pad3) -> SW_C3
- SW39 pad 2: Net-(SW39-Pad2) -> SW_R7
- SW4 pad 2: Net-(SW4-Pad2) -> SW_R1
- SW40 pad 1: Net-(SW34-Pad3) -> SW_C4
- SW40 pad 2: Net-(SW40-Pad2) -> SW_R7
- SW41 pad 1: Net-(SW35-Pad3) -> SW_C5
- SW41 pad 2: Net-(SW41-Pad2) -> SW_R7
- SW42 pad 1: Net-(SW36-Pad3) -> Net-(SW12-Pad1)
- SW42 pad 2: unconnected-(SW42-Pad2) -> SW_R7
- SW43 pad 1: Net-(SW37-Pad3) -> SW_C1
- SW43 pad 2: Net-(SW43-Pad2) -> SW_R8
- SW44 pad 1: Net-(SW38-Pad3) -> SW_C2
- SW44 pad 2: Net-(SW44-Pad2) -> SW_R8
- SW45 pad 1: Net-(SW39-Pad3) -> SW_C3
- SW45 pad 2: Net-(SW45-Pad2) -> SW_R8
- SW46 pad 1: Net-(SW40-Pad3) -> SW_C4
- SW46 pad 2: Net-(SW46-Pad2) -> SW_R8
- SW47 pad 1: Net-(SW41-Pad3) -> SW_C5
- SW47 pad 2: Net-(SW47-Pad2) -> SW_R8
- SW48 pad 1: Net-(SW42-Pad3) -> Net-(SW12-Pad1)
- SW48 pad 2: unconnected-(SW48-Pad2) -> SW_R8
- SW5 pad 2: Net-(SW5-Pad2) -> SW_R1
- SW6 pad 1: SW_C6 -> Net-(SW12-Pad1)
- SW6 pad 2: unconnected-(SW6-Pad2) -> SW_R1
- SW7 pad 1: Net-(SW1-Pad3) -> SW_C1
- SW7 pad 2: Net-(SW7-Pad2) -> SW_R2
- SW8 pad 1: Net-(SW2-Pad3) -> SW_C2
- SW8 pad 2: Net-(SW8-Pad2) -> SW_R2
- SW9 pad 1: Net-(SW3-Pad3) -> SW_C3
- SW9 pad 2: Net-(SW10-Pad4) -> SW_R2
- U3 pad 13: unconnected-(U3-IN-Pad13) -> VBUS
- U6 pad 9: unconnected-(U6-EPAD-Pad9) -> GND
Routing:
- net SW_R8: track 0.00 -> 24.9 mm

Commit message: ers
Parts:
- removed U2: NCP1117-3.3_SOT223, Package_TO_SOT_SMD:SOT-223-3_TabPin2
- added C35: 22u, Capacitor_SMD:C_0402_1005Metric, F.Cu at (130.9, 100.5)
- added C36: 22u, Capacitor_SMD:C_0402_1005Metric, F.Cu at (130.9, 102.5)
- added C37: 22u, Capacitor_SMD:C_0402_1005Metric, F.Cu at (130.9, 104.4)
- added D5: D_Schottky, Diode_SMD:D_0402_1005Metric, F.Cu at (96.2, 113.0)
- added DS1: E28GA-T-CW250-N, AAAAA:HIROSE_FH12S-40S-0.5SH_55_, F.Cu at (110.8, 73.4)
- added IC1: ISL91107IRTNZ-T, AAAAA:QFN50P300X400X80-21N, F.Cu at (32.1, 57.6)
- moved SW43 266.1 mm to (135.0, 230.0)
- moved SW44 244.9 mm to (155.0, 230.0)
- moved SW45 227.0 mm to (175.0, 230.0)
- moved SW46 216.6 mm to (185.0, 230.0)
- moved SW47 207.3 mm to (199.6, 230.0)
- moved SW48 203.0 mm to (205.0, 230.0)
- moved SW41 136.7 mm to (195.0, 200.0)
- moved SW42 129.6 mm to (205.0, 200.0)
- moved SW31 116.4 mm to (135.0, 170.0)
- moved R15 103.0 mm to (-6.65, 85.1)
- moved U1 103.0 mm to (-4.77, 65.5)
- moved C26 103.0 mm to (-14.3, 68.9)
- moved SW49 103.0 mm to (98.8, 161.1)
- moved SW32 102.6 mm to (155.0, 170.0)
- moved SW37 102.5 mm to (135.0, 200.0)
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Connections:
- SW12 pad 1: Net-(SW12-Pad1) -> SW_C6
- SW18 pad 1: Net-(SW12-Pad1) -> SW_C6
- SW24 pad 1: Net-(SW12-Pad1) -> SW_C6
- SW30 pad 1: Net-(SW12-Pad1) -> SW_C6
- SW36 pad 1: Net-(SW12-Pad1) -> SW_C6
- SW42 pad 1: Net-(SW12-Pad1) -> SW_C6
- SW48 pad 1: Net-(SW12-Pad1) -> SW_C6
- SW6 pad 1: Net-(SW12-Pad1) -> SW_C6

Commit message: screen, moving buttons
Parts:
- moved SW45 217.3 mm to (28.0, 70.0)
- moved SW47 215.0 mm to (56.0, 70.0)
- moved SW46 214.6 mm to (42.0, 70.0)
- moved SW44 213.3 mm to (14.0, 70.0)
- moved SW43 209.3 mm to (0.00, 70.0)
- moved SW48 209.3 mm to (70.0, 70.0)
- moved SW39 203.0 mm to (28.0, 60.0)
- moved SW40 200.1 mm to (42.0, 60.0)
- moved SW38 198.7 mm to (14.0, 60.0)
- moved SW41 197.3 mm to (56.0, 60.0)
- moved SW37 194.5 mm to (0.00, 60.0)
- moved SW42 194.5 mm to (70.0, 60.0)
- moved SW33 189.8 mm to (28.0, 50.0)
- moved SW34 186.7 mm to (42.0, 50.0)
- moved SW32 185.2 mm to (14.0, 50.0)
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Other:
- board outline added: 100 x 180 mm

Commit message: moving things
Parts:
- C24, C25, C28, C33, C35, C36, C37, IC1, U3: moved to B.Cu
- moved C34 290.3 mm to (68.0, 45.0), turned to 180 degrees
- moved D5 250.7 mm to (22.5, 21.5)
- moved C35 226.0 mm to (77.4, 24.4), turned to 180 degrees
- moved C36 226.0 mm to (77.4, 26.4), turned to 180 degrees
- moved C37 226.0 mm to (77.4, 28.3), turned to 180 degrees
- moved DS1 221.4 mm to (50.7, 31.0), turned to 90 degrees
- moved U5 219.6 mm to (60.2, 27.2), turned to -135 degrees
- moved C30 211.5 mm to (27.9, 27.2)
- moved C31 211.5 mm to (27.9, 29.1)
- moved C32 211.5 mm to (27.9, 31.1)
- moved U4 211.5 mm to (31.9, 33.5)
- moved U6 184.2 mm to (64.0, 42.0), turned to 180 degrees
- moved C27 165.1 mm to (71.0, 45.0), turned to 180 degrees
- moved C33 155.3 mm to (25.0, 46.5), turned to 180 degrees
- moved C24 149.7 mm to (27.9, 40.6), turned to 180 degrees
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Connections:
- DS1 pad 10: unconnected-(DS1-~{CSX}-Pad10) -> CSX
- DS1 pad 11: unconnected-(DS1-DCX-Pad11) -> DCX
- DS1 pad 12: unconnected-(DS1-~{WRX}-Pad12) -> WRX
- DS1 pad 13: unconnected-(DS1-~{RDX}-Pad13) -> RDX
- DS1 pad 14: unconnected-(DS1-DB0-Pad14) -> DB0
- DS1 pad 15: unconnected-(DS1-DB1-Pad15) -> DB1
- DS1 pad 16: unconnected-(DS1-DB2-Pad16) -> DB2
- DS1 pad 17: unconnected-(DS1-DB3-Pad17) -> DB3
- DS1 pad 18: unconnected-(DS1-DB4-Pad18) -> DB4
- DS1 pad 19: unconnected-(DS1-DB5-Pad19) -> DB5
- DS1 pad 20: unconnected-(DS1-DB6-Pad20) -> DB6
- DS1 pad 21: unconnected-(DS1-DB7-Pad21) -> DB7
- DS1 pad 3: unconnected-(DS1-IM0-Pad3) -> GND
- DS1 pad 34: unconnected-(DS1-DOTCLK-Pad34) -> GND
- DS1 pad 35: unconnected-(DS1-ENABLE-Pad35) -> GND
- DS1 pad 38: unconnected-(DS1-~{RESX}-Pad38) -> DISPLAY_RESET
- DS1 pad 4: unconnected-(DS1-IM1-Pad4) -> GND
- DS1 pad 5: unconnected-(DS1-IM2-Pad5) -> GND
- DS1 pad 6: unconnected-(DS1-IM3-Pad6) -> GND
- U5 pad 28: unconnected-(U5-GPIO27-Pad28) -> RDX
- U5 pad 36: unconnected-(U5-GPIO28-Pad36) -> WRX
- U5 pad 37: unconnected-(U5-GPIO29-Pad37) -> DCX
- U5 pad 38: unconnected-(U5-GPIO30-Pad38) -> CSX
- U5 pad 39: unconnected-(U5-GPIO31-Pad39) -> DISPLAY_RESET
- U5 pad 40: unconnected-(U5-GPIO32-Pad40) -> DB0
- U5 pad 42: unconnected-(U5-GPIO33-Pad42) -> DB1
- U5 pad 43: unconnected-(U5-GPIO34-Pad43) -> DB2
- U5 pad 44: unconnected-(U5-GPIO35-Pad44) -> DB3
- U5 pad 45: unconnected-(U5-GPIO36-Pad45) -> DB4
- U5 pad 46: unconnected-(U5-GPIO37-Pad46) -> DB5
- U5 pad 47: unconnected-(U5-GPIO38-Pad47) -> DB6
- U5 pad 48: unconnected-(U5-GPIO39-Pad48) -> DB7
Routing:
- net SW_C1: track 0.00 -> 85.0 mm
- net SW_C4: track 0.00 -> 85.0 mm
- net SW_C3: track 0.00 -> 85.0 mm
- net SW_C2: track 0.00 -> 85.0 mm
- net SW_C5: track 0.00 -> 84.8 mm
- net SW_R7: track 0.00 -> 29.5 mm
- net SW_R6: track 0.00 -> 29.5 mm
- net SW_R5: track 0.00 -> 29.5 mm
- net SW_R4: track 0.00 -> 29.5 mm
- net SW_R3: track 0.00 -> 29.5 mm
- net SW_R2: track 0.00 -> 29.5 mm
- net SW_R1: track 0.00 -> 29.5 mm
- net SW_R8: track 24.9 -> 29.5 mm
Other:
- board size 100 x 180 mm -> 100 x 160 mm

Commit message: more moving things
Parts:
- moved C35 45.7 mm to (32.3, 17.3)
- moved C36 45.7 mm to (32.3, 19.2)
- moved C37 45.7 mm to (32.3, 21.2)
- moved IC1 45.7 mm to (36.5, 20.5)
- moved C26 35.5 mm to (56.7, 3.15)
- moved R15 35.5 mm to (65.3, 7.53)
- moved U1 35.5 mm to (52.5, 8.50)
- moved SW49 35.5 mm to (123.5, 110.6)
- moved C10 34.8 mm to (53.5, 38.0)
- moved C27 31.0 mm to (71.0, 14.0)
- moved C34 31.0 mm to (68.0, 14.0)
- moved U6 31.0 mm to (64.0, 11.0)
- moved C12 29.8 mm to (51.5, 33.0)
- moved C11 28.3 mm to (51.5, 28.5), turned to 180 degrees
- moved C13 27.8 mm to (58.0, 38.5), turned to -90 degrees
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Connections:
- U5 pad 1: SW_R4 -> CSX
- U5 pad 11: SW_C4 -> DB4
- U5 pad 12: SW_C5 -> DB5
- U5 pad 13: SW_C6 -> DB6
- U5 pad 14: unconnected-(U5-GPIO15-Pad14) -> DB7
- U5 pad 16: unconnected-(U5-GPIO16-Pad16) -> DISPLAY_RESET
- U5 pad 2: SW_R5 -> DCX
- U5 pad 21: unconnected-(U5-GPIO21-Pad21) -> SW_R4
- U5 pad 22: unconnected-(U5-GPIO22-Pad22) -> SW_R5
- U5 pad 23: unconnected-(U5-GPIO23-Pad23) -> SW_R6
- U5 pad 25: unconnected-(U5-GPIO24-Pad25) -> SW_R7
- U5 pad 26: unconnected-(U5-GPIO25-Pad26) -> SW_R8
- U5 pad 27: unconnected-(U5-GPIO26-Pad27) -> SW_R3
- U5 pad 28: RDX -> SW_R2
- U5 pad 3: SW_R6 -> WRX
- U5 pad 36: WRX -> SW_R1
- U5 pad 37: DCX -> SW_C1
- U5 pad 38: CSX -> SW_C2
- U5 pad 39: DISPLAY_RESET -> SW_C3
- U5 pad 4: SW_R7 -> RDX
- U5 pad 40: DB0 -> SW_C4
- U5 pad 42: DB1 -> SW_C5
- U5 pad 43: DB2 -> SW_C6
- U5 pad 44: DB3 -> unconnected-(U5-GPIO35-Pad44)
- U5 pad 45: DB4 -> unconnected-(U5-GPIO36-Pad45)
- U5 pad 46: DB5 -> unconnected-(U5-GPIO37-Pad46)
- U5 pad 47: DB6 -> unconnected-(U5-GPIO38-Pad47)
- U5 pad 48: DB7 -> unconnected-(U5-GPIO39-Pad48)
- U5 pad 6: SW_R8 -> DB0
- U5 pad 7: SW_C1 -> DB1
- U5 pad 8: SW_C2 -> DB2
- U5 pad 9: SW_C3 -> DB3

Commit message: various things
Parts:
- removed C28, C29, C30: 4.7u, Capacitor_SMD:C_0402_1005Metric
- removed C32: 220n, Capacitor_SMD:C_0402_1005Metric
- removed D5: D_Schottky, Diode_SMD:D_0402_1005Metric
- removed U4: TPS61165DBV, Package_TO_SOT_SMD:SOT-23-6
- added C1: 100n, Capacitor_SMD:C_0402_1005Metric, B.Cu at (33.2, 95.8)
- added C17: 100n, Capacitor_SMD:C_0402_1005Metric, B.Cu at (28.3, 75.7)
- added C18: 10u, Capacitor_SMD:C_0402_1005Metric, B.Cu at (40.0, 60.0)
- added C19: 100n, Capacitor_SMD:C_0402_1005Metric, B.Cu at (37.1, 74.5)
- added C3: 4.7u, Capacitor_SMD:C_0402_1005Metric, B.Cu at (23.2, 75.1)
- added C38: 10u, Capacitor_SMD:C_0402_1005Metric, B.Cu at (37.1, 76.0)
- added C7: 100n, Capacitor_SMD:C_0402_1005Metric, B.Cu at (23.2, 80.1)
- added J1: USB_C_Receptacle_USB2.0_16P, Connector_USB:USB_C_Receptacle_Amphenol_124019772112A, B.Cu at (1.59, 89.3)
- added L2: 10u, Inductor_SMD:L_0201_0603Metric, B.Cu at (35.0, 50.0)
- added L3: 1u, Inductor_SMD:L_0201_0603Metric, B.Cu at (19.9, 40.3)
- added R1: 33, Resistor_SMD:R_0201_0603Metric, B.Cu at (12.6, 74.6)
- added R10: 10k, Resistor_SMD:R_0201_0603Metric, B.Cu at (49.7, 115.0)
- added R11: 46k4, Resistor_SMD:R_0201_0603Metric, B.Cu at (-9.83, 74.1)
- added R12: 46k4, Resistor_SMD:R_0201_0603Metric, B.Cu at (-1.61, 62.6)
- added R13: 46k4, Resistor_SMD:R_0201_0603Metric, B.Cu at (-1.61, 64.3)
- added R14: 0.33, Resistor_SMD:R_0201_0603Metric, B.Cu at (28.3, 57.2)
- added R17: 10k, Resistor_SMD:R_0201_0603Metric, B.Cu at (35.3, 115.0)
- added R3: 27, Resistor_SMD:R_0201_0603Metric, B.Cu at (7.90, 89.4)
- added R4: 27, Resistor_SMD:R_0201_0603Metric, B.Cu at (7.90, 88.4)
- added R5: 5.1K, Resistor_SMD:R_0201_0603Metric, B.Cu at (10.3, 73.6)
- added R6: 5.1K, Resistor_SMD:R_0201_0603Metric, B.Cu at (10.3, 75.3)
- added R7: 10k, Resistor_SMD:R_0201_0603Metric, B.Cu at (-1.61, 72.6)
- added R8: 2k, Resistor_SMD:R_0201_0603Metric, B.Cu at (-11.6, 70.1)
- added R9: 3.09k, Resistor_SMD:R_0201_0603Metric, B.Cu at (-11.6, 71.8)
- added U2: TPS92200D2DDC, Package_TO_SOT_SMD:SOT-23-6, B.Cu at (37.0, 53.5)
- added Y1: ABM8-272-T3, AAAAA:ABM8272T3, B.Cu at (84.1, 86.6)
- C10, C11, C12, C13, C14, C15, C16, C2, C26, C27, C34, C4, C5, C6, C8, C9, L1, R15, R2, SW49, U1, U5, U6: moved to B.Cu
- C31: value 10u -> 100n; moved to B.Cu
- DS1: value E28GA-T-CW250-N -> E26RE-RW300-N; footprint AAAAA:HIROSE_FH12S-40S-0.5SH_55_ -> AAAAA:HRS_FH12-45S-0.5SH_55_; moved to B.Cu
- moved C2 111.2 mm to (11.1, 101.8), turned to -90 degrees
- moved C27 106.7 mm to (29.4, 112.2), turned to 0 degrees
- moved C34 104.5 mm to (32.4, 112.2), turned to 0 degrees
- moved C6 103.0 mm to (17.0, 101.8), turned to -90 degrees
- moved U6 102.0 mm to (36.4, 109.2), turned to 0 degrees
- moved R15 97.9 mm to (51.0, 104.4), turned to 180 degrees
- moved U1 97.5 mm to (63.8, 105.3), turned to 180 degrees
- moved C26 96.9 mm to (59.6, 100.0), turned to 180 degrees
- moved L1 83.0 mm to (22.1, 92.3), turned to -90 degrees
- moved C16 82.8 mm to (26.2, 89.5)
- moved C9 78.4 mm to (29.6, 95.7), turned to -90 degrees
- moved C8 76.0 mm to (26.1, 90.5), turned to 180 degrees
- moved C15 68.4 mm to (25.8, 85.6), turned to -90 degrees
- moved C14 67.3 mm to (37.3, 95.9), turned to 90 degrees
- moved U5 63.3 mm to (33.5, 89.0), turned to -90 degrees
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Connections:
- C31 pad 2: GND -> Net-(U2-BOOT)
- DS1 pad 10: CSX -> unconnected-(DS1-HSYNC-Pad10)
- DS1 pad 11: DCX -> unconnected-(DS1-DOTCLK-Pad11)
- DS1 pad 12: WRX -> unconnected-(DS1-ENABLE-Pad12)
- DS1 pad 13: RDX -> +3V3
- DS1 pad 14: DB0 -> SPI_RS
- DS1 pad 15: DB1 -> SPI_SCK
- DS1 pad 16: DB2 -> CSX
- DS1 pad 17: DB3 -> DISPLAY_RESET
- DS1 pad 18: DB4 -> unconnected-(DS1-DB17-Pad18)
- DS1 pad 19: DB5 -> unconnected-(DS1-DB16-Pad19)
- DS1 pad 20: DB6 -> unconnected-(DS1-DB15-Pad20)
- DS1 pad 21: DB7 -> unconnected-(DS1-DB14-Pad21)
- DS1 pad 3: GND -> +3V3
- DS1 pad 34: GND -> unconnected-(DS1-DB1-Pad34)
- DS1 pad 35: GND -> unconnected-(DS1-DB0-Pad35)
- DS1 pad 36: unconnected-(DS1-HSYNC-Pad36) -> LEDK
- DS1 pad 37: unconnected-(DS1-VSYNC-Pad37) -> LEDK
- DS1 pad 38: DISPLAY_RESET -> LEDK
- DS1 pad 4: GND -> +3V3
- DS1 pad 41: (no net) -> unconnected-(DS1-XR_(NC)-Pad41)
- DS1 pad 42: (no net) -> unconnected-(DS1-YU_(NC)-Pad42)
- DS1 pad 5: GND -> +3V3
- DS1 pad 6: GND -> +3V3
- DS1 pad 7: unconnected-(DS1-TE-Pad7) -> +3V3
- DS1 pad 8: +3V3 -> MOSI
- DS1 pad 9: +3V3 -> unconnected-(DS1-VSYNC-Pad9)
- U5 pad 1: CSX -> SPI_RS
- U5 pad 11: DB4 -> unconnected-(U5-GPIO12-Pad11)
- U5 pad 12: DB5 -> unconnected-(U5-GPIO13-Pad12)
- U5 pad 13: DB6 -> unconnected-(U5-GPIO14-Pad13)
- U5 pad 14: DB7 -> DISPLAY_BCKLGHT
- U5 pad 2: DCX -> CSX
- U5 pad 3: WRX -> SPI_SCK
- U5 pad 4: RDX -> MOSI
- U5 pad 6: DB0 -> unconnected-(U5-GPIO8-Pad6)
- U5 pad 7: DB1 -> unconnected-(U5-GPIO9-Pad7)
- U5 pad 78: SW_R1 -> unconnected-(U5-GPIO1-Pad78)
- U5 pad 79: SW_R2 -> unconnected-(U5-GPIO2-Pad79)
- U5 pad 8: DB2 -> unconnected-(U5-GPIO10-Pad8)
- U5 pad 80: SW_R3 -> unconnected-(U5-GPIO3-Pad80)
- U5 pad 9: DB3 -> unconnected-(U5-GPIO11-Pad9)
Routing:
- net +3V3: track 0.00 -> 5.27 mm
- net GND: track 0.00 -> 0.99 mm
Other:
- board size 100 x 160 mm -> 100 x 111.4 mm
